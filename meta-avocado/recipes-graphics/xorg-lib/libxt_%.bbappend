EXTRA_OECONF:append = " --disable-selective-werror"
